IMAGE_INSTALL_append_imx7d-pico-voicehat = " tfa98xx"
IMAGE_INSTALL_append_imx8mq-voicehat = " tfa98xx"
