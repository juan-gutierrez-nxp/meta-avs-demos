IMAGE_INSTALL_append_imx7d-pico-voicehat = " tfa98xx"
