IMAGE_INSTALL_append = " tfa98xx"
