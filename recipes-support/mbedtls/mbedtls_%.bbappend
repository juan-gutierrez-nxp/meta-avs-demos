do_install_append() {
    rm ${D}${bindir}/hello
}
